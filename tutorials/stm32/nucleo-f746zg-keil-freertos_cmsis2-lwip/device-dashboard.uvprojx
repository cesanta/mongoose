# Keil uVision project device-dashboard.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: device-dashboard
  c flags: Optim=6 OneElfS=1 uC99=1
  c define: HTTP_URL=\"http://0.0.0.0/\"
  c misc: -W -Wall -Wextra -Wundef -Wshadow -Wdouble-promotion -Wno-unused-parameter -Wconversion -Wno-sign-conversion -Wno-implicit-int-conversion -fno-common -fdata-sections
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6918
  group Source Group 1
    ./: hal.h main.c net.c packed_fs.c syscalls.c mongoose.c mongoose_config.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Inc/: stm32f7xx_it.h
target Test (6160000::V6.16::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: as above
  output: firmware +hex
  c flags: Optim=6 OneElfS=1 uC99=1
  c define: HTTP_URL=\"http://0.0.0.0/\" UART_DEBUG=USART1
  c misc: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6918
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 1.12.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:ETH 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:RNG 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.5, Network:API 2.2.0, Network:CORE 2.2.0, Network:Driver:Ethernet 2.2.0, Network:Interface:Ethernet 2.2.0, Network:RTOS 2.2.0
