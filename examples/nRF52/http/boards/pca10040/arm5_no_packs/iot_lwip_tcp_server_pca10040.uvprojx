# Keil uVision project iot_lwip_tcp_server_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s1xx_iot (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: __HEAP_SIZE=4096 BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET s1xx SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0 MG_DISABLE_HTTP_DIGEST_AUTH MG_DISABLE_MD5 MG_DISABLE_HTTP_KEEP_ALIVE MG_ENABLE_HTTP_SSI=0 MG_ENABLE_HTTP_STREAMING_MULTIPART CS_PLATFORM=CS_P_NRF52 CS_ENABLE_STDIO NRF_LOG_USES_RTT  ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\nrf5_iot_sdk\examples\bsp;..\..\..\..\nrf5_iot_sdk\components\device;..\..\..\..\nrf5_iot_sdk\components\toolchain;..\..\..\..\nrf5_iot_sdk\components\ble\common;..\..\..\..\nrf5_iot_sdk\components\drivers_nrf\common;..\..\..\..\nrf5_iot_sdk\components\drivers_nrf\delay;..\..\..\..\nrf5_iot_sdk\components\drivers_nrf\gpiote;..\..\..\..\nrf5_iot_sdk\components\drivers_nrf\hal;..\..\..\..\nrf5_iot_sdk\components\drivers_nrf\pstorage;..\..\..\..\nrf5_iot_sdk\components\drivers_nrf\uart;..\..\..\..\nrf5_iot_sdk\components\drivers_nrf\config;..\..\..\..\nrf5_iot_sdk\components\iot\ble_6lowpan;..\..\..\..\nrf5_iot_sdk\components\iot\ble_ipsp;..\..\..\..\nrf5_iot_sdk\components\iot\common;..\..\..\..\nrf5_iot_sdk\components\iot\context_manager;..\..\..\..\nrf5_iot_sdk\components\iot\include;..\..\..\..\nrf5_iot_sdk\components\iot\errno;..\..\..\..\nrf5_iot_sdk\components\iot\iot_timer;..\..\..\..\nrf5_iot_sdk\components\iot\medium;..\..\..\..\nrf5_iot_sdk\components\iot\medium\ble_ncfgs;..\..\..\..\nrf5_iot_sdk\components\iot\medium\include;..\..\..\..\nrf5_iot_sdk\components\iot\medium\commissioning;..\..\..\..\nrf5_iot_sdk\components\libraries\button;..\..\..\..\nrf5_iot_sdk\components\libraries\fifo;..\..\..\..\nrf5_iot_sdk\components\libraries\mem_manager;..\..\..\..\nrf5_iot_sdk\components\libraries\scheduler;..\..\..\..\nrf5_iot_sdk\components\libraries\timer;..\..\..\..\nrf5_iot_sdk\components\libraries\trace;..\..\..\..\nrf5_iot_sdk\components\libraries\uart;..\..\..\..\nrf5_iot_sdk\components\libraries\util;..\..\..\..\nrf5_iot_sdk\components\softdevice\common\softdevice_handler;..\..\..\..\nrf5_iot_sdk\components\softdevice\s1xx_iot\headers;..\..\..\..\nrf5_iot_sdk\components\softdevice\s1xx_iot\headers\nrf52;..\..\..\..\nrf5_iot_sdk\external\lwip\src\include;..\..\..\..\nrf5_iot_sdk\external\lwip\src\include\netif;..\..\..\..\nrf5_iot_sdk\external\lwip\src\include\lwip;..\..\..\..\nrf5_iot_sdk\external\lwip\src\port;..\..\..\..\nrf5_iot_sdk\external\lwip\src\port\arch;..\..\..;..\..\..\rtt\RTT;..\..\..\rtt\Syscalls;..\..\..\..\..\..
  asm define: __HEAP_SIZE=4096 BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET s1xx SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002800 size 0xd800
  group Application
    ../../../: main.c bleconfig.c bleconfig.h myboard.h
    ../../../config/: sdk_config.h
  group Board Support
    ../../../../nrf5_iot_sdk/examples/bsp/: bsp.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group lwIP
    ../../../../nrf5_iot_sdk/external/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c memp.c netif.c pbuf.c raw.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../nrf5_iot_sdk/external/lwip/src/core/ipv6/: dhcp6.c icmp6.c inet6.c ip6.c ip6_addr.c mld6.c nd6.c
    ../../../../nrf5_iot_sdk/external/lwip/src/core/ipv4/: icmp.c ip4.c ip4_addr.c
    ../../../../nrf5_iot_sdk/external/lwip/src/port/: nrf_platform_port.c
  group nRF_BLE
    ../../../../nrf5_iot_sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../nrf5_iot_sdk/components/libraries/uart/: app_uart_fifo.c
    ../../../../nrf5_iot_sdk/components/drivers_nrf/delay/: nrf_delay.c
    ../../../../nrf5_iot_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nrf5_iot_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../nrf5_iot_sdk/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../nrf5_iot_sdk/components/drivers_nrf/pstorage/: pstorage.c
  group nRF_IoT
    ../../../../nrf5_iot_sdk/components/iot/ble_6lowpan/lib/: ble_6lowpan.lib
    ../../../../nrf5_iot_sdk/components/iot/errno/: errno.c
    ../../../../nrf5_iot_sdk/components/iot/context_manager/: iot_context_manager.c
    ../../../../nrf5_iot_sdk/components/iot/iot_timer/: iot_timer.c
    ../../../../nrf5_iot_sdk/components/iot/medium/: ipv6_medium_ble.c
    ../../../../nrf5_iot_sdk/components/iot/common/: ipv6_parse.c
  group nRF_IoT_Commissioning
    ../../../../nrf5_iot_sdk/components/iot/medium/ble_ncfgs/: ble_ncfgs.c
    ../../../../nrf5_iot_sdk/components/iot/medium/commissioning/: commissioning.c
  group nRF_Libraries
    ../../../../nrf5_iot_sdk/components/libraries/button/: app_button.c
    ../../../../nrf5_iot_sdk/components/libraries/util/: app_error.c nrf_assert.c
    ../../../../nrf5_iot_sdk/components/libraries/fifo/: app_fifo.c
    ../../../../nrf5_iot_sdk/components/libraries/scheduler/: app_scheduler.c
    ../../../../nrf5_iot_sdk/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../nrf5_iot_sdk/components/libraries/trace/: app_trace.c
    ../../../../nrf5_iot_sdk/components/libraries/mem_manager/: mem_manager.c
    ../../../../nrf5_iot_sdk/components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../nrf5_iot_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group RTT
    ../../../rtt/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
    ../../../rtt/Syscalls/: RTT_Syscalls_KEIL.c
  group Mongoose
    ../../../../../../: mongoose.c
  group ::Device
    RTE/Device/nRF52832_xxAA/: arm_startup_nrf52.s system_nrf52.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.5
