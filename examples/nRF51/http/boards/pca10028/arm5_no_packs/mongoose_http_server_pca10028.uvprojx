# Keil uVision project mongoose_http_server_pca10028.uvprojx, settings and files
target nrf51422_xxac_s1xx_iot (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=1024 BOARD_PCA10028 BLE_STACK_SUPPORT_REQD S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 MG_DISABLE_HTTP_DIGEST_AUTH MG_DISABLE_MD5 MG_DISABLE_HTTP_KEEP_ALIVE MG_ENABLE_HTTP_SSI=0 MG_ENABLE_HTTP_STREAMING_MULTIPART CS_PLATFORM=CS_P_NRF51 CS_ENABLE_STDIO NRF_LOG_USES_RTT  ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..\..\..\config;..\..\..;..\..\..\..\nrf51_iot_sdk\examples\bsp;..\..\..\..\nrf51_iot_sdk\components\softdevice\s1xx_iot\headers;..\..\..\..\nrf51_iot_sdk\components\ble\common;..\..\..\..\nrf51_iot_sdk\components\drivers_nrf\uart;..\..\..\..\nrf51_iot_sdk\components\libraries\timer;..\..\..\..\nrf51_iot_sdk\components\softdevice\common\softdevice_handler;..\..\..\..\nrf51_iot_sdk\components\libraries\scheduler;..\..\..\..\nrf51_iot_sdk\components\libraries\button;..\..\..\..\nrf51_iot_sdk\external\lwip\src\include;..\..\..\..\nrf51_iot_sdk\external\lwip\src\include\netif;..\..\..\..\nrf51_iot_sdk\external\lwip\src\port;..\..\..\..\nrf51_iot_sdk\external\lwip\src\port\arch;..\..\..\..\nrf51_iot_sdk\components\iot\ble_6lowpan;..\..\..\..\nrf51_iot_sdk\components\device;..\..\..\..\nrf51_iot_sdk\components\toolchain;..\..\..\..\nrf51_iot_sdk\components\libraries\util;..\..\..\..\nrf51_iot_sdk\components\libraries\fifo;..\..\..\..\nrf51_iot_sdk\components\drivers_nrf\gpiote;..\..\..\..\nrf51_iot_sdk\components\drivers_nrf\config;..\..\..\..\nrf51_iot_sdk\components\drivers_nrf\common;..\..\..\..\nrf51_iot_sdk\components\drivers_nrf\hal;..\..\..\..\nrf51_iot_sdk\components\libraries\mem_manager;..\..\..\..\nrf51_iot_sdk\components\iot\include;..\..\..\..\nrf51_iot_sdk\components\iot\context_manager;..\..\..\..\nrf51_iot_sdk\components\iot\ble_ipsp;..\..\..\..\nrf51_iot_sdk\components\libraries\trace;..\..\..\..\..\..;..\..\..\rtt\RTT
  asm define: __HEAP_SIZE=1024 BOARD_PCA10028 BLE_STACK_SUPPORT_REQD S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF_LOG_USES_RTT  ENABLE_DEBUG_LOG_SUPPORT
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c bleconfig.c bleconfig.h myboard.h
  group Documentation
    ../../../: Abstract.txt license.txt
  group Third Parties
    ../../../../nrf51_iot_sdk/external/lwip/lib/: liblwip.lib
    ../../../../nrf51_iot_sdk/external/lwip/src/port/: nrf_platform_port.c
  group nRF_BLE
    ../../../../nrf51_iot_sdk/components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_Drivers
    ../../../../nrf51_iot_sdk/components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../nrf51_iot_sdk/components/drivers_nrf/hal/: nrf_delay.c
    ../../../../nrf51_iot_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nrf51_iot_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_IoT
    ../../../../nrf51_iot_sdk/components/iot/ble_6lowpan/lib/: ble_6lowpan.lib
    ../../../../nrf51_iot_sdk/components/iot/context_manager/: iot_context_manager.c
  group nRF_Libraries
    ../../../../nrf51_iot_sdk/components/libraries/button/: app_button.c
    ../../../../nrf51_iot_sdk/components/libraries/util/: app_error.c nrf_assert.c
    ../../../../nrf51_iot_sdk/components/libraries/fifo/: app_fifo.c
    ../../../../nrf51_iot_sdk/components/libraries/scheduler/: app_scheduler.c
    ../../../../nrf51_iot_sdk/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../nrf51_iot_sdk/components/libraries/trace/: app_trace.c
    ../../../../nrf51_iot_sdk/components/libraries/mem_manager/: mem_manager.c
  group nRF_SoftDevice
    ../../../../nrf51_iot_sdk/components/softdevice/s1xx_iot/doc/: s1xx-iot-prototype2_licence_agreement.txt
    ../../../../nrf51_iot_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group Mongoose
    ../../../../../../: mongoose.c
  group RTT
    ../../../rtt/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
    ../../../rtt/Syscalls/: RTT_Syscalls_KEIL.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
