# Keil uVision project device-dashboard.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: device-dashboard
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3
  c define: HTTP_URL=\"http://0.0.0.0/\"
  c misc: -W -Wall -Wextra -Wundef -Wshadow -Wdouble-promotion -Wno-unused-parameter -Wconversion -Wno-sign-conversion -Wno-implicit-int-conversion -fno-common -fdata-sections
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: hal.h main.c net.c packed_fs.c syscalls.c mongoose.c mongoose_config.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Inc/: stm32f4xx_it.h
target Test (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: firmware +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3
  c define: HTTP_URL=\"http://0.0.0.0/\" UART_DEBUG=USART1
  c misc: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, CMSIS:CORE 5.6.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:ETH 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:RNG 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:Startup 2.6.3
